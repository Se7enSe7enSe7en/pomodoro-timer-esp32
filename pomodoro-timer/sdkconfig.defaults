## pomodoro-timer/sdkconfig.defaults
```kconfig
CONFIG_SPIRAM=y
CONFIG_SPIRAM_MODE_OCT=y
CONFIG_SPIRAM_SPEED=80
CONFIG_SPIRAM_TYPE_AUTO=y
```
